# Keil uVision project Project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Source\App;..\..\Source\Bsp;..\..\Source\Components;..\..\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Libraries\CMSIS\CM3\CoreSupport;..\..\..\bus_driver;..\..\..\device_driver;..\..\..\driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/: main.c
  group Bsp/Hadware
    ../../Source/Bsp/: stm32f10x_it.c
    ../../../bus_driver/: i2c_hw.c onewire_hw.c spi_hw.c
  group Components
    ../../../device_driver/: i2c_bitops.c i2c_core.c onewire_bitops.c spi_bitops.c spi_core.c
  group Driver
    ../../../driver/: 25xx.c ad7684.c ad5290.c tmc2660.c 24clxx.c ad7793.c
  group Libraries
    ../../Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
